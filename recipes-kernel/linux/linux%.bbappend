FILESEXTRAPATHS:prepend := "${THISDIR}/files:"  
SRC_URI += "file://f2fs.cfg"
